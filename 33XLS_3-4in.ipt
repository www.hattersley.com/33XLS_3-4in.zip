# Autodesk Inventor part: 33XLS_3-4in
## iProperties
Created: 2011-03
Part Number: 33XLS_3-4in
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
